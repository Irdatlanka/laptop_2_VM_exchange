<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\iolinkmaster_test_5_to_EWARM.ewp</path>
  </project>
  <batchBuild />
</workspace>
