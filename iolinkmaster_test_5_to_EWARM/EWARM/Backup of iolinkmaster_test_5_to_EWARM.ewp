# IAR project Backup of iolinkmaster_test_5_to_EWARM.ewp, settings and files
configuration iolinkmaster_test_5_to_EWARM (ARM, debug)
  General.OGChipSelectEditMenu: STM32U585RI ST STM32U585RI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 6
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; USE_HAL_DRIVER; STM32U585xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32U5xx_HAL_Driver/Inc; ../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32U5xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: iolinkmaster_test_5_to_EWARM.hex
  ILINK.IlinkOutputFile: iolinkmaster_test_5_to_EWARM.out
  ILINK.IlinkIcfFile: stm32u585xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32u585xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32u5xx_it.c stm32u5xx_hal_msp.c stm32u5xx_hal_timebase_tim.c
  group Drivers/STM32U5xx_HAL_Driver
    ../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_ll_utils.c stm32u5xx_ll_exti.c stm32u5xx_hal_adc.c stm32u5xx_hal_adc_ex.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_cortex.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_exti.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_icache.c stm32u5xx_hal_spi.c stm32u5xx_hal_spi_ex.c stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c stm32u5xx_ll_ucpd.c stm32u5xx_ll_gpio.c stm32u5xx_ll_lpgpio.c stm32u5xx_ll_dma.c stm32u5xx_hal_pcd.c stm32u5xx_hal_pcd_ex.c stm32u5xx_ll_usb.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32u5xx.c
